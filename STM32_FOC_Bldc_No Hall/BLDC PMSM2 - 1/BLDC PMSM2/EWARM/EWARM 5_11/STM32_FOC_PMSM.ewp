# IAR project STM32_FOC_PMSM.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..; ..\..\STM32F10XFWLIB\inc; ..\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: STM32_FOC_PMSM.srec
  ILINK.IlinkOutputFile: STM32_FOC_PMSM.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; VECT_TAB_FLASH
  ICCARM.CCOptStrategy: 0
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group include
    ../inc/: MC_Clarke_Park.h MC_const.h MC_Display.h MC_FOC_Drive.h MC_Globals.h MC_Keys.h MC_MotorControl_Layer.h MC_PID_regulators.h MC_State_Observer.h MC_State_Observer_interface.h MC_type.h stm32f10x_encoder.h stm32f10x_hall.h stm32f10x_lcd.h stm32f10x_MCdac.h stm32f10x_MClib.h stm32f10x_svpwm_1shunt.h stm32f10x_svpwm_3shunt.h stm32f10x_svpwm_ics.h stm32f10x_Timebase.h
  group lib
    LIB/: MC_FOC_Methods.o MC_State_Observer_lib.o
  group Parameters .h files
    ../inc/: MC_Control_Param.h MC_encoder_param.h MC_hall_prm.h MC_PMSM_motor_param.h MC_pwm_1shunt_prm.h MC_pwm_3shunt_prm.h MC_pwm_ics_prm.h MC_State_Observer_param.h STM32F10x_MCconf.h
  group source
    ../src/: main.c MC_Clarke_Park.c MC_Display.c MC_FOC_Drive.c MC_Globals.c MC_Keys.c MC_MotorControl_Layer.c MC_PID_regulators.c MC_State_Observer_Interface.c stm32f10x_encoder.c stm32f10x_hall.c stm32f10x_lcd.c stm32f10x_MCdac.c stm32f10x_svpwm_1shunt.c stm32f10x_svpwm_3shunt.c stm32f10x_svpwm_ics.c stm32f10x_Timebase.c
    ../: stm32f10x_it.c
  group STM32F10XFWLIB
    ../../STM32F10XFWLIB/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
